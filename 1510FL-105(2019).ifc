Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2020-04-08T15:30:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.4.0.0 - Alternate UI 17.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 08 15:30:47 2020 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\{016882A5-D390-4335-B5ED-CBDF86F2B0A5}\ifc * Database version: 5507 * Database creation date: Wed Apr 08 15:30:46 2020 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 08 15:30:46 2020 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 08 15:30:46 2020 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 1510F-105 Washbasin faucet, Energy Class A, 1510FL-105(2019):1510F-105 Washbasin faucet, Energy Class A:321233
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - InletConnectionSize: 10 mm; Projection: 103 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 1510FL-105(2019); ConvergoRefNr: 0087-2003-0002-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_78; Uniclass2015Description: Shower manual water supply sets; Uniclass2015Reference: Pr_40_20_87_78; Version: 1; VersionDate: 02/04/2020
Type - Green Building Properties(Type) - Backflow Prevention EN1717: AA; Customs Code: 84818011; EAN Number: 6414150095757; EN Standard: EN 817; Noise Class: I (ISO 3822) Oras lab; RSK Number: 8278175
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/1510FL-105; Catalog Drawing URL: http://static.oras.com/catdrw/1510FL-105; Class: Single lever;Green Building; Dimension Drawing URL: http://static.oras.com/dimdrw/1510FL-105; FDV Document URL: http://www.oras.com/datasheet/1510FL-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1510FL-105; Group: Washbasin Faucets; Manufacturer: Oras; Market: SWE; Model: 1510FL-105 Washbasin faucet, Energy Class A; Name_en: 1510FL-105 Washbasin faucet, Energy Class A; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 540 x 146 x 59; Package Weight: 1.475 kg; Product Code: 1510FL-105; Product Datasheet: http://www.oras.com/datasheet/1510FL-105/en; Product Family: Oras Swea; Product Image URL: http://static.oras.com/image/1510FL-105; Product URL: http://static.oras.com/1510FL-105; Type Name: 1510F-105 Washbasin faucet, Energy Class A
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Rapid Installation System; Aerator: CASCADE®; Connection: Flexible Inlet Pipes; Eco Flow At 300kPa: 0.00176573 m3/s; Extensions: Chain Holder; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Installation and Maintenance: http://static.oras.com/manual/1510FL-105; Installation Type: Deck mounted; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: 35 Cartridge; Spare Parts: http://static.oras.com/sp/1510FL-105; Temperature: Temperature limiter
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Green Building; CodePerformance: n/a; Color: Chrome; Constituents: Single lever; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1510FL-105(2019); Features: n/a; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1510FL-105; Name: 1510FL-105 Washbasin faucet, Energy Class A; ReplacementCost: n/a; Shape: Sculptured; Size: 50x135x135 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1510FL-105; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 1510F-105 Washbasin faucet, Energy Class A
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0331575 m2; Volume: 0.000915009 m3
Identity Data - Mark: 2
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1510FL-105(2019): 1510F-105 Washbasin faucet, Energy Class A; Family and Type: 1510FL-105(2019): 1510F-105 Washbasin faucet, Energy Class A; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1510FL-105(2019): 1510F-105 Washbasin faucet, Energy Class A; Type Id: 1510FL-105(2019): 1510F-105 Washbasin faucet, Energy Class A; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
